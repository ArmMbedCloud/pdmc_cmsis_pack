# Keil uVision project pdmc_example.uvprojx, settings and files
target pdmc_example (6140000::V6.14::ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: pdmc_example
  AfterMake: fromelf.exe --bin --output=objects/pdmc_example.bin objects/pdmc_example.axf
  AfterMake: python tools/combine.py -b tools/mbed-bootloader.bin -a objects/pdmc_example.bin -o objects/pdmc_example_combined.bin -c 0x8400 -d 0x8000
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\;.\include;.\platform\include;.\platform\KEIL;.\platform\KEIL\include
  memory RVCT4: ROM 0x8008400 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group pdmc user settings
    ./RTE/IoT_Client/: mbed_cloud_client_user_config.h
    ./: README.md
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
  group Source
    ./: application_init.cpp blinky.cpp certificate_enrollment_user_cb.cpp Driver_Flash.c memory_tests.cpp pdmc_main.cpp resource.cpp update_ui_example.cpp app_platform_setup.c
    ./platform/: pal_plat_rot_insecure.c
    ./platform/KEIL/: mcc_common_button_and_led.c mcc_common_setup.c
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, IoT Client:Pelion Device Management Client 4.4.0, Security:mbed TLS 2.17.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:SPI 1.2.0, CMSIS Driver:WiFi:ISM43362 1.9.0, Device:STM32Cube HAL:Common 1.11.1, Device:STM32Cube HAL:Cortex 1.11.1, Device:STM32Cube HAL:DMA 1.11.1, Device:STM32Cube HAL:Flash 1.11.1, Device:STM32Cube HAL:GPIO 1.11.1, Device:STM32Cube HAL:PWR 1.11.1, Device:STM32Cube HAL:RCC 1.11.1, Device:STM32Cube HAL:RNG 1.11.1, Device:STM32Cube HAL:SPI 1.11.1, Device:STM32Cube HAL:UART 1.11.1, Device:Startup 1.3.1, IoT Utility:Socket:WiFi 1.0.0
